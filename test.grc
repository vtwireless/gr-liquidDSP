options:
  parameters:
    generate_options: qt_gui
    id: test2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: resamplerate
  id: variable_qtgui_range
  parameters:
    label: resamplerate
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.02'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_UNIFORM
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_probe_rate_0_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ofdmflexframegen_1
  id: ofdmflexframegen
  parameters:
    command: ./less_complex_float
    in_type: complex
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: resamplerate
    type: ccf
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: samp_rate
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_KAISER
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: samp_rate
    fftsize: '1024'
    name: '"4x"'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_KAISER
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_probe_rate_0_0, '0']
- [analog_fastnoise_source_x_0, '0', ofdmflexframegen_1, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_probe_rate_0_0, rate, blocks_message_debug_0_0, print]
- [blocks_throttle_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [ofdmflexframegen_1, '0', blocks_probe_rate_0, '0']
- [ofdmflexframegen_1, '0', blocks_throttle_0, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
