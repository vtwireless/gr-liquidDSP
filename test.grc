options:
  parameters:
    generate_options: qt_gui
    id: test2
    output_language: python
    title: test2
  states: {}

blocks:
- name: resamp1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '10'
    value: '1'
  states: {state: disabled}
- name: resamp2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '10'
    value: '1'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: blocks_file_descriptor_sink_0
  id: blocks_file_descriptor_sink
  parameters:
    fd: '2'
    type: byte
  states: {}
- name: blocks_file_descriptor_source_0
  id: blocks_file_descriptor_source
  parameters:
    fd: '0'
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: byte
  states: {}
- name: ofdmflexframegen_0
  id: ofdmflexframegen
  parameters:
    in_type: byte
    mcs: 8 - r8/9 64-QAM
  states: {}
- name: ofdmflexframesync_0
  id: ofdmflexframesync
  parameters:
    out_type: byte
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: resamp1
    type: ccf
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: resamp2
    type: ccf
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: resamp1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: gen
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: resamp2
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}

connections:
- [blocks_file_descriptor_source_0, '0', ofdmflexframegen_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_1, print]
- [ofdmflexframegen_0, '0', ofdmflexframesync_0, '0']
- [ofdmflexframegen_0, '0', pfb_arb_resampler_xxx_0, '0']
- [ofdmflexframegen_0, '0', qtgui_sink_x_0_0, '0']
- [ofdmflexframesync_0, '0', blocks_file_descriptor_sink_0, '0']
- [ofdmflexframesync_0, '0', blocks_probe_rate_0, '0']
- [pfb_arb_resampler_xxx_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', ofdmflexframesync_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', qtgui_sink_x_0_1, '0']

metadata:
  file_format: 1
