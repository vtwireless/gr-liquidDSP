options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: blocks_file_descriptor_sink_0
  id: blocks_file_descriptor_sink
  parameters:
    fd: '1'
    type: byte
  states: {}
- name: blocks_file_descriptor_source_0
  id: blocks_file_descriptor_source
  parameters:
    fd: '0'
    repeat: 'False'
    type: byte
  states: {}
- name: ofdmflexframegen_0
  id: ofdmflexframegen
  parameters:
    in_type: byte
    mcs: 8 - r8/9 64-QAM
  states: {}
- name: ofdmflexframesync_0
  id: ofdmflexframesync
  parameters:
    out_type: byte
  states: {}

connections:
- [blocks_file_descriptor_source_0, '0', ofdmflexframegen_0, '0']
- [ofdmflexframegen_0, '0', ofdmflexframesync_0, '0']
- [ofdmflexframesync_0, '0', blocks_file_descriptor_sink_0, '0']

metadata:
  file_format: 1
