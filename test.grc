options:
  parameters:
    generate_options: qt_gui
    id: test2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out_xxx
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: in_xxx
    repeat: 'False'
    type: byte
  states: {}
- name: ofdmflexframegen_0
  id: ofdmflexframegen
  parameters:
    in_type: byte
    mcs: 5 - r2/3 16-QAM
  states: {}
- name: ofdmflexframesync_0
  id: ofdmflexframesync
  parameters:
    out_type: byte
  states: {}

connections:
- [blocks_file_source_0, '0', ofdmflexframegen_0, '0']
- [ofdmflexframegen_0, '0', ofdmflexframesync_0, '0']
- [ofdmflexframesync_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
